# IAR project F103ZET6_PRJ.ewp, settings and files
configuration F103ZET6_PRJ (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\FreeModbus\port; ..\Drivers\FreeModbus\modbus\ascii; ..\Drivers\FreeModbus\modbus\include; ..\Drivers\FreeModbus\modbus\rtu; ..\Drivers\FreeModbus\modbus\tcp; ..\Drivers\USART
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: F103ZET6_PRJ.hex
  ILINK.IlinkOutputFile: F103ZET6_PRJ.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: bsp.c dma.c freertos.c gpio.c main.c rtc.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/FreeModbus/modbus
    ../Drivers/FreeModbus/modbus/: mb.c mb_m.c
  group Drivers/FreeModbus/modbus/ascii
    ../Drivers/FreeModbus/modbus/ascii/: mbascii.c
  group Drivers/FreeModbus/modbus/functions
    ../Drivers/FreeModbus/modbus/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
  group Drivers/FreeModbus/modbus/rtu
    ../Drivers/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
  group Drivers/FreeModbus/modbus/tcp
    ../Drivers/FreeModbus/modbus/tcp/: mbtcp.c
  group Drivers/FreeModbus/port
    ../Drivers/FreeModbus/port/: user_mb_app.c user_mb_app_m.c
  group Drivers/FreeModbus/port/rtt
    ../Drivers/FreeModbus/port/rtt/: e_port.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/USART
    ../Drivers/USART/: CircularQueue.c UART_Port.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
